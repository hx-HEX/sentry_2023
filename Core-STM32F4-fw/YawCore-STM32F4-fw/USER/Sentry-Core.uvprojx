# Keil uVision project Sentry-Core.uvprojx, settings and files
target Sentry-Core (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sentry-Core +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK
  c include: ..\Bsp;..\Core\Inc;..\Drivers\STM32F4_LIB\inc;..\Drivers\CMSIS\Core;..\UserApp;..\Drivers\CMSIS\Device;..\Middlewares\FreeRTOS\include;..\UserApp\freertos;..\Bsp\gpio;..\Bsp\communication;..\Bsp\gimbal;..\Bsp\aim_assist;..\Bsp\capacitor;..\Bsp\dij_rc;..\Bsp\encoder;..\Bsp\navigation;..\Bsp\referee;..\Bsp\vofa;..\UserApp\protocol;..\Robot\actuators;..\Robot\algorithms;..\Robot\instances;..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\Bsp\chassis_core;..\Bsp\left_gimbal;..\Bsp\right_gimbal;..\Bsp\yaw_gimbal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Bsp
    ../Bsp/gpio/: led.cpp led.h photogate.cpp photogate.h
    ../Bsp/communication/: usart_interface.cpp usart_interface.h communication.cpp communication.h can_interface.cpp can_interface.h
    ../Bsp/dij_rc/: dijrc.cpp djirc.h
    ../Bsp/vofa/: vofa.cpp vofa.h
    ../Bsp/navigation/: navigation.cpp navigation.h
    ../Bsp/referee/: referee.cpp referee.h
    ../Bsp/encoder/: encoder.cpp encoder.h
    ../Bsp/chassis_core/: chassis_core.cpp chassis_core.h
    ../Bsp/left_gimbal/: left_gimbal.cpp left_gimbal.h
    ../Bsp/right_gimbal/: right_gimbal.cpp right_gimbal.h
    ../Bsp/yaw_gimbal/: yaw_gimbal.cpp yaw_gimbal.h
  group Core
    ../Core/Src/: bsp_init.c can.c delay.c gpio.c systick.c tim.c usart.c main.c stm32f4xx_it.c system_stm32f4xx.c
    ../Core/Inc/: bsp_init.h can.h delay.h gpio.h systick.h tim.h usart.h main.h stm32f4xx_it.h
  group Drivers
    ../Drivers/STM32F4_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
  group Robot
    ../Robot/actuators/: gm6020.cpp gm6020.h m2006.cpp m2006.h m3508.cpp m3508.h
    ../Robot/algorithms/: adrc.cpp adrc.h common_math.cpp common_math.h ewma.cpp ewma.h kalman.cpp kalman.h mahony.cpp mahony.h pid.cpp pid.h smc.cpp smc.h
    ../Robot/instances/: sentry_robot.cpp sentry_robot.h
  group Startup
    ../startup/: startup_stm32f40_41xxx.s
  group UserApp
    ../UserApp/: user_main.cpp user_main.h user_task.cpp user_task.h user_callback.cpp user_callback.h user_global.cpp user_global.h
    ../UserApp/protocol/: uart_protocol.cpp uart_protocol.h verify.cpp verify.h can_protocol.cpp can_protocol.h
software components: CMSIS:CORE 5.5.0
