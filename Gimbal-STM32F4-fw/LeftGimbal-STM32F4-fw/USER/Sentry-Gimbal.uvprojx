# Keil uVision project Sentry-Gimbal.uvprojx, settings and files
target Sentry-Core (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sentry-Gimbal
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK
  c include: ..\Bsp;..\Core\Inc;..\Drivers\CMSIS\Core;..\Drivers\STM32F4_LIB\inc;..\UserApp;..\Drivers\CMSIS\Device;..\Middlewares\FreeRTOS\include;..\UserApp\freertos;..\Bsp\bmi088;..\Bsp\communication;..\Bsp\encoder;..\Bsp\gimbal;..\Bsp\gpio;..\Bsp\gun_shift;..\Bsp\vofa;..\UserApp\protocol;..\Robot\actuators;..\Robot\algorithms;..\Robot\instances;..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\Bsp\aim_assist
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Bsp
    ../Bsp/bmi088/: bmi088.cpp bmi088.h bmi088reg.h
    ../Bsp/communication/: can_interface.cpp can_interface.h communication.cpp communication.h usart_interface.cpp usart_interface.h
    ../Bsp/encoder/: encoder.cpp encoder.h
    ../Bsp/gimbal/: gimbal.cpp gimbal.h
    ../Bsp/gpio/: led.cpp led.h
    ../Bsp/vofa/: vofa.cpp vofa.h
    ../Bsp/aim_assist/: aim_assist.cpp aim_assist.h
  group Core
    ../Core/Src/: bsp_init.c can.c delay.c gpio.c systick.c spi.c tim.c usart.c main.c stm32f4xx_it.c system_stm32f4xx.c
    ../Core/Inc/: bsp_init.h can.h delay.h gpio.h systick.h spi.h tim.h usart.h main.h stm32f4xx_it.h
  group Drivers
    ../Drivers/STM32F4_LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/include/: FreeRTOSConfig.h
  group Robot
    ../Robot/actuators/: gm6020.cpp gm6020.h m2006.cpp m2006.h m3508.cpp m3508.h
    ../Robot/algorithms/: adrc.cpp adrc.h common_math.cpp common_math.h ewma.cpp ewma.h kalman.cpp kalman.h mahony.cpp mahony.h pid.cpp pid.h smc.cpp smc.h
    ../Robot/instances/: sentry_robot.cpp sentry_robot.h
  group Startup
    ../startup/: startup_stm32f40_41xxx.s
  group UserApp
    ../UserApp/: system_monitor.h user_callback.cpp user_callback.h user_global.cpp user_global.h user_main.cpp user_main.h user_task.cpp user_task.h
    ../UserApp/protocol/: can_protocol.cpp can_protocol.h uart_protocol.cpp uart_protocol.h verify.cpp verify.h
